FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI +=  "file://kernel-debug.cfg \
            "
